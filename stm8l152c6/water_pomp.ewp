# IAR project water_pomp.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: water_pomp.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: lcd_1602.c lcd_1602.h main.c stm8l15x.h stm8l15x_clk.c stm8l15x_clk.h stm8l15x_conf.h stm8l15x_exti.c stm8l15x_exti.h stm8l15x_gpio.c stm8l15x_gpio.h stm8l15x_rtc.c stm8l15x_rtc.h stm8l15x_syscfg.c stm8l15x_syscfg.h stm8l15x_tim1.c stm8l15x_tim1.h stm8l15x_tim2.c stm8l15x_tim2.h stm8l15x_tim4.c stm8l15x_tim4.h stm8l15x_usart.c stm8l15x_usart.h stm8l15x_wwdg.c stm8l15x_wwdg.h
